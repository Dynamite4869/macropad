## boards/shields/1759471827649/Kconfig.defconfig
```kconfig
if SHIELD_1759471827649

config ZMK_KEYBOARD_NAME
    default "1759471827649"

endif
```
